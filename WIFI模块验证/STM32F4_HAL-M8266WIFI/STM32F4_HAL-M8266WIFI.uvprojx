# Keil uVision project STM32F4_HAL-M8266WIFI.uvprojx, settings and files
target STM32F4_HAL-M8266WIFI (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4_HAL-M8266WIFI
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F40_41xxx,_RTE_
  c include: .\CORE;.\STM32F4xx_HAL_Driver\Inc;.\STM32F4xx_HAL_Driver\Inc\Legacy;.\SYSTEM;.\HARDWARE\LED;.\HARDWARE\KEY;.\M8266WIFI;.\USER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ./CORE/: startup_stm32f407xx.s
  group HALLIB
    ./STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group SYSTEM
    ./SYSTEM/: delay.c sys.c
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/KEY/: key.c
  group M8266WIFI
    ./M8266WIFI/: M8266HostIf_STM32xx.c M8266WIFIDrv_STM32F4xx.a M8266WIFI_ops.c test_m8266wifi.c
  group USER
    ./USER/: system_stm32f4xx.c main.c
  group README
    ./: readme.txt
